# Keil uVision project YH-F407.uvprojx, settings and files
target LED (6140001::V6.14.1::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YH-F407
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\led;..\User\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/touch/: bsp_i2c_touch.c gt5xx.c
    ../User/lcd/: bsp_nt35510_lcd.c
    ../User/BSP/: adc.c stm32f4xx_hal_msp.c tim.c
  group DOC
    ../Doc/: readme.txt
  group lvgl
    ../User/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../User/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../User/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../User/lvgl/src/extra/: lv_extra.c
    ../User/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../User/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../User/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../User/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../User/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../User/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../User/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../User/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../User/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../User/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../User/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../User/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../User/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../User/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../User/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../User/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../User/lvgl/src/extra/others/msg/: lv_msg.c
    ../User/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../User/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../User/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../User/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../User/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../User/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../User/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../User/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../User/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../User/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../User/lvgl/src/extra/widgets/led/: lv_led.c
    ../User/lvgl/src/extra/widgets/list/: lv_list.c
    ../User/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../User/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../User/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../User/lvgl/src/extra/widgets/span/: lv_span.c
    ../User/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../User/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../User/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../User/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../User/lvgl/src/extra/widgets/win/: lv_win.c
    ../User/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../User/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../User/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../User/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl\porting
    ../User/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ../User/: lv_conf.h
  group UI
    ../User/GUI/: GUI.c icon_normal.c icon_press.c nahida.c icon2_normal.c icon2_press.c
software components: Compiler:I/O:STDERR 1.2.0
